# Keil uVision project TlsCheck4.uvprojx, settings and files
target TlsCheck4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TlsCheck4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;      ../Middlewares/Third_Party/LwIP/src/include;      ../Middlewares/Third_Party/LwIP/system;      ../Drivers/STM32F7xx_HAL_Driver/Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;      ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;      ../Middlewares/Third_Party/LwIP/src/include/lwip;      ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;      ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;      ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;      ../Middlewares/Third_Party/LwIP/src/include/netif;      ../Middlewares/Third_Party/LwIP/src/include/compat/posix;      ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;      ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;      ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;      ../Middlewares/Third_Party/LwIP/src/include/compat/stdc;      ../Middlewares/Third_Party/LwIP/system/arch;      ../Middlewares/Third_Party/mbedTLS/include/mbedtls;      ../Middlewares/Third_Party/mbedTLS/include;      ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/LwIP/src/apps/altcp_tls
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: main.c freertos.c lwip.c ethernetif.c mbedtls.c net_sockets.c retarget.c threading_alt.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_usart.c stm32f7xx_ll_gpio.c stm32f7xx_ll_dma.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
    ../Middlewares/Third_Party/LwIP/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
software components: CMSIS:CORE 4.3.0
